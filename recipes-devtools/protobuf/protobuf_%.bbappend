# CMake requires binaries to exist in sysroot, even if they have wrong architecture.
SYSROOT_DIRS += "${bindir}"
